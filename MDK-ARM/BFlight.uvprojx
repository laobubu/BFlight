# Keil uVision project BFlight.uvprojx, settings and files
target BFlight Configuration (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BFlight Configuration +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Inc;       ..\Drivers\STM32F4xx_HAL_Driver\Inc;       ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;       ..\Drivers\CMSIS\Include;       ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;       ..\Src\Fly
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Fly
    ../Src/Fly/: DataPacker.c FlyMain.c Param.c STM32_IT.c TMessager.c TNavigator.c TPilot.c FlyBasic.c pin_map.h sys.c TCCD.c
  group Fly/Hardware
    ../Src/Fly/Hardware/: CCD.c HMC5883L.c IIC.c Laser.c MPU6050.c MPU6050_DMP.c MS5611_I2C.c Ultrasonic.c USART.c XRotor.c HyperCCD.c ADNS3080.c Magnet.c oled.c
  group Fly/Algorithm
    ../Src/Fly/Algorithm/: AlgorithmBasic.c AvgFilter.c PID.c StatusCalc.c StatusCtrl.c Plan.c Filters.c
